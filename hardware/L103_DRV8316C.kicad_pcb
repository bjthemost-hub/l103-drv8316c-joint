# Repository bjthemost-hub/l103-drv8316c-joint

File README.md:

# L103 + DRV8316C 关节电机驱动板（软硬件 + 两级行星减速机）

[中文](README.md) | [English](README.en.md)

一套可以直接拿去复现的关节电机方案：**CH32L103 主控 + DRV8316C 三相驱动 + MT6701 磁编码器**
的驱动板，跑 FOC 的固件、Qt 上位机，以及配套的**两级行星减速机（J 版，25:1）**。

> 实拍演示：CH32L103 + DRV8316C 板 + MT6701 + 两级行星减速机，上位机经 CAN 使能、走位、连续转。
> 视频里的电源表与背景已由 AI 打码处理。

MIT License。

---

## 目录

| 目录 | 内容 |
|---|---|
| `hardware/` | KiCad 工程（原理图 + PCB，KiCad 10），`gerber/` 里是出板文件 |
| `firmware/` | CH32L103 固件（FOC V2），Makefile + MounRiver Studio 工程两套都在 |
| `gearbox-J/` | 两级行星减速机 J 版（25:1）：**只给 STEP** + 打印装配说明 |
| `docs/` | 调参手册、低速 FOC 调试方法与坑、编码器磁场核对、硬件说明 |

---

## 一、硬件

**设计值**（出处：`hardware/L103_DRV8316C.kicad_sch` 网表 + `docs/硬件说明_原README.md`）：

| 项 | 值 |
|---|---|
| 主控 | `CH32L103K8U6`（QFN-32，96 MHz） |
| 三相驱动 | `DRV8316CT`（VFQFN-40，内置三个半桥 / 电荷泵 / buck），**3x PWM 模式**（MODE 经 47 kΩ 到 AVDD） |
| 电流检测 | 8316C 内置三路低边 CSA，`SOx` → 330 Ω + 22 pF → `MOT_x_V` → `PA1/PA2/PA3` |
| CSA 增益 | GAIN 跳线默认 Hi-Z = **0.3 V/A**（R49/R50 DNP） |
| OCP | `OCP/SR` 经 R47 = 0R 到 AGND（触发值见 DRV8316C 手册，**不是电机工作电流**） |
| 编码器 | `MT6701` 磁编码器（SSI，14 位），径向充磁磁铁 6 mm × 2.5 mm、1 对极 |
| CAN | `MAX3051EKA+T`，1 Mbps |
| 母线 | 24 V 标称（固件默认 `MOTOR_VBUS_DEF = 24.0 V`，有采样时以实测为准） |
| 电机（参考） | `MY-4621F`，24N22P → **11 极对**（`firmware/User/board.h`） |

> 编码器气隙：MT6701 手册给的是 0.5 / 1.0 / 2.0 mm（最小 / 典型 / 最大），
> 我们实物目测约 1.5–2.0 mm（未用塞尺量），全周 `Mg` 状态位正常，详见 `docs/`。

## 二、固件

- 三环：电流环 20 kHz、速度环 1 kHz、位置环 200 Hz；相电流在 PWM 谷值同步采样。
- 速度反馈：MT6701 走 **SPI1 + DMA**，10 kHz 取帧，PLL 带宽默认 150 Hz。
- 通信：CAN 1 Mbps（节点号 1–63）或串口 115200（调试口，命令表见固件 `docs/命令表.md`）。
- 参数：16 项可调参数存在 Flash 配置页，上电读回；读不到就用编译默认值。

### 编译

```bash
# 需要 WCH RISC-V GCC（MounRiver Studio 自带）
make -B TOOLCHAIN_PATH="<MounRiver>/resources/app/resources/win32/components/WCH/Toolchain/RISC-V Embedded GCC"
```

### 烧写

```bash
make flash OPENOCD='"<MounRiver>/resources/app/resources/win32/components/WCH/OpenOCD/OpenOCD/bin/openocd.exe"' \
           OPENOCD_SCRIPTS='<MounRiver>/resources/app/resources/win32/components/WCH/OpenOCD/OpenOCD/bin'
```

> **`make flash` 会整片擦掉配置页（0x0800FC00）** —— 烧完要重新 `SAVE` 一次参数。

也可以直接用 MounRiver Studio 2 打开 `firmware/L103_DRV8316C_FOC_V2.wvproj`，F7 编译、一键下载。

### 实测（2026-10-23，24 V 母线，空载）

- 对齐：`3.20 V` 给约 0.8 s，对齐电流峰值 0.85 A，结束 `aligned=1`。
- 速度环：给定 10.47 rad/s，实测 8.5–11.7 rad/s。
- 位置序列：18 趟 × 2 段、700 rpm，每段 298–321 ms，到位残差 ±0.02 rad（约 1.1°）。

## 三、上位机

上位机在独立仓库 [`l103-servo-gui`](https://github.com/bjthemost-hub/l103-servo-gui)（同一套 GUI 也支持 DRV8313 板）。

Qt 工程（`L103MotorControl.pro`，Qt 5/6 均可编），功能：参数页签（读写 RAM / 存 Flash）、
对齐 / 使能 / 速度 / 走位 / 序列、状态与波形显示，通道可选串口或 CAN。

## 四、减速机（J 版，25:1）

两级行星减速机，针对打印件设计。零件、打印参数、装配顺序、强度与转速边界见
`gearbox-J/README.md` 与同目录的原始文档。

## 五、安全与边界

- 这是**开发板级**方案，没有做 UL/CE 之类的认证；上电前请自行确认母线与散热。
- 驱动板默认电流上限 1.80 A，改之前先确认电机额定值。
- 让机构动起来的第一件事永远是**开环**（不读反馈），确认转向、相电流、有没有某相不发力，再进闭环。
- 一旦发现不转、抖动、转速不跟随，**立刻停机**，不要靠抬电压硬顶。

## 六、关于 AI 辅助

本项目的硬件设计、固件、上位机、减速机模型与文档，在设计、编码、调试和写作过程中**大量使用了 AI 辅助**
（OpenAI Codex / GPT 系列模型）。AI 生成的代码与文本均经人工审阅，并在真实板卡与台架上逐项验证；
文中实测数据全部来自实机测试。AI 是工具，不是作者 —— 设计取舍、验证标准与最终结论由人负责。

## 七、许可

MIT，见 `LICENSE`。硬件设计文件与固件源码同样按 MIT 发布。

## KiCad design hardware/L103_DRV8316C.kicad_pcb

Parts:
C1, C23, C25, C30, C41, C42, C43, C48: 100nF; C_0603_1608Metric
C7, C31, C32: 22uF/35V; C_1206_3216Metric
C24: 10uF/63V; C_0805_2012Metric
C26, C27, C46: 22uF/10V; C_0805_2012Metric
C44: 1uF/16V; C_0603_1608Metric
C45: 47nF/50V; C_0603_1608Metric
C47: 1uF; C_0603_1608Metric
C49, C50, C51: 22pF; C_0603_1608Metric
D3: SS16; D_SMA
D4: LED_RED; LED_0603_1608Metric
D6: SMBJ28A; D_SMB; BREAKDOWN VOLTAGE 28.9V; MANUFACTURER PART SMBJ28A; LCSC PART NAME SMBJ28A
F1: 5 A / 32 VDC; Fuse_Littelfuse-NANO2-451_453
FB2: 600R; L_0805_2012Metric
L2: ANR4030T470M; L_APV_ANR4030; MPN ANR4030T470M; LCSC Part C6364808
Q1: DMP6023LEQ-13; SOT-223-3_TabPin2
R5: 10 k; R_0805_2012Metric
R6: 100 k; R_0805_2012Metric
R8: 49K9; R_0603_1608Metric
R9, R15: 100K; R_0603_1608Metric
R10: 30K1; R_0603_1608Metric
R13: 4k7; R_0603_1608Metric
R18: 1k; R_0603_1608Metric
R25: 10k; R_0603_1608Metric
R41: 22R; R_0603_1608Metric
R42: 47k; R_0402_1005Metric
R43, R44, R45: 330R; R_0603_1608Metric
R46: 5.1k; R_0603_1608Metric
R47: 0R; R_0402_1005Metric
R48, R50, R52: 0R; R_0402_1005Metric; not fitted
R49, R51: 47k; R_0402_1005Metric; not fitted
TP31: U; tp2.2x1.2_th
TP32: V; tp2.2x1.2_th
TP33: W; tp2.2x1.2_th
TP34: 24VIN; tp2.2x1.2_th
TP35: GND; tp2.2x1.2_th
U2: LMR16006XDDCR; SOT-23-6; MPN LMR16006XDDCR; LCSC Part C87080
U6: DRV8316CT; VFQFN-40_L5.0-W7.0-P0.50-TL-EP
ZD1: BZT52C12; D_SOD-123

Connections:
+3V3: C48.1, R46.1, U6.37 (VREF/ILIM); also elsewhere on the board
+3V3DC: C26.1, C27.1, L2.1, R9.1; also elsewhere on the board
+24VIN: F1.1, TP34.1 (1_1)
+24VSRC: C7.1, C30.1, C31.1, C32.1, C41.1, C42.1, C43.1, C44.1, D6.1 (K), FB2.2, Q1.3 (S), R6.1, R8.1, R25.1, U6.9 (VM), U6.10 (VM), U6.11 (VM), ZD1.1 (K)
/DRV8316C/AVDD: C47.1, R42.2, R48.2, R49.2, R51.2, U6.25 (AVDD)
/DRV8316C/Q1_G: Q1.1 (G), R5.1, R6.2, ZD1.2 (A)
/DRV8316C/VIN_F: F1.2, Q1.2 (D)
ADC0: R18.2; also elsewhere on the board
EN_A: U6.28 (INLA); also elsewhere on the board
EN_B: U6.30 (INLB); also elsewhere on the board
EN_C: U6.32 (INLC); also elsewhere on the board
GND: C1.2, C7.2, C24.2, C25.2, C26.2, C27.2, C30.2, C31.2, C32.2, C41.2, C42.2, C43.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, D3.2 (A), D4.1 (K), D6.2 (A), R5.2, R10.1, R13.2, R47.1, R50.2, R52.2, TP35.1 (1_1), U2.2 (GND), U6.2 (AGND), U6.4 (GND_BK), U6.12 (PGND), U6.15 (PGND), U6.18 (PGND), U6.24 (VSEL_BK), U6.26 (AGND), U6.41 (EP); also elsewhere on the board
MOT_A_V: C49.1, R43.2; also elsewhere on the board
MOT_B_V: C50.1, R44.2; also elsewhere on the board
MOT_C_V: C51.1, R45.2; also elsewhere on the board
unnamed: C1.1, R8.2, R13.1, R18.1
unnamed: C23.1, D3.1 (K), L2.2, U2.6 (SW)
unnamed: D4.2 (A), R25.2
unnamed: TP31.1 (1_1), U6.13 (OUTA), U6.14 (OUTA)
unnamed: TP32.1 (1_1), U6.16 (OUTB), U6.17 (OUTB)
unnamed: TP33.1 (1_1), U6.19 (OUTC), U6.20 (OUTC)
unnamed: C23.2, U2.1 (CB)
unnamed: R9.2, R10.2, U2.3 (FB)
unnamed: R15.2, U2.4 (SHDN)
unnamed: C24.1, C25.1, FB2.1, R15.1, U2.5 (VIN)
unnamed: C44.2, U6.8 (CP)
unnamed: C45.2, U6.7 (CPH)
unnamed: C45.1, U6.6 (CPL)
unnamed: C46.1, R41.2, U6.3 (FB_BK)
unnamed: R49.1, R50.1, U6.36 (GAIN)
unnamed: R42.1, U6.33 (MODE)
unnamed: R47.2, R48.1, U6.35 (OCP/SR)
unnamed: R51.1, R52.1, U6.34 (SLEW)
unnamed: R43.1, U6.40 (SOA)
unnamed: R44.1, U6.39 (SOB)
unnamed: R45.1, U6.38 (SOC)
unnamed: R41.1, U6.5 (SW_BK)
PWM_A: U6.27 (INHA); also elsewhere on the board
PWM_B: U6.29 (INHB); also elsewhere on the board
PWM_C: U6.31 (INHC); also elsewhere on the board
nFAULT: R46.2, U6.22 (nFAULT); also elsewhere on the board
nSLEEP: U6.23 (nSLEEP); also elsewhere on the board

Notes on the sheet:
R47/R48 只贴一个
DRV8316C 配置电阻作用 (硬件配置版, 手册 SLVSH07 四电平输入表)
R42 47k MODE(33) -> AVDD : 3x PWM 模式, 本板已装
(该脚焊 0R 会进 3x+限流模式, SOx 不可用, 本板禁止)
R49 47k GAIN(36) -> AVDD : CSA 增益 0.6 V/A, 本板不装
R50 0R GAIN(36) -> AGND : CSA 增益 0.15 V/A, 本板不装
R49/R50 都不装 = 悬空 = 0.3 V/A (本板现状)
R51 47k SLEW(34) -> AVDD : 压摆率 125 V/us, 本板不装
R52 0R SLEW(34) -> AGND : 压摆率 25 V/us, 本板不装
R51/R52 都不装 = 悬空 = 50 V/us (本板现状)
R47 0R OCP/SR(35) -> AGND : OCP 16 A typ (10~22 A), 本板已装
R48 0R OCP/SR(35) -> AVDD : OCP 24 A typ (15~30 A), 本板不装
R47/R48 同时装 = AGND 与 AVDD 短路, 禁止
另: buck R_BK = R41 22R (SW_BK -> FB_BK), C_BK = C46 22uF/10V
VREF/ILIM(37) = +3V3 -> 中点 VREF/2 ; SOx = VREF/2 +/- GAIN x IOUT
VSEL_BK(24) = AGND -> buck 3.3V

Parts:
C2: 100n; C_0603_1608Metric
C3, C11, C12: 10uF; C_0603_1608Metric
C21, C22: 100nF; C_0603_1608Metric
D1: LED绿; LED_0603_GREEN
D2: LED红; LED_0603_RED
FB3: 600R; L_0603_1608Metric
J1: 1.27; PinHeader_1x06_P1.27mm_Vertical
J6: WAFER-MX1.25-4PCB; CONN-SMD_4P-P1.25_XUNPU_WAFER-MX1.25-4PCB; MPN WAFER-MX1.25-4PCB; LCSC Part C3029388
J11: FH34SRJ-6S-0.5SH; FFC-SMD_6P-P0.50_FH34SRJ-6S-0.5SH; MPN FH34SRJ-6S-0.5SH(50); LCSC Part C224194
R1, R3, R4, R26, R27: 4.7k; R_0603_1608Metric
R2: 10k; R_0603_1608Metric
R12: 120R; R_0805_2012Metric
R17, R21: 860; R_0603_1608Metric
U1: WAFER-PH2.0-2PZZ; CONN-TH_2P-P2.00_HC-PH-2A-M; CURRENT RATING 2A; VOLTAGE RATING 250V; MANUFACTURER PART WAFER-PH2.0-2PZZ; LCSC PART NAME 1x2P 间距:2mm 直插 系列:PH
U3: CH32L103K8U6; QFN-32-1EP_4x4mm_P0.4mm_EP2.65x2.65mm
U4: MAX3051EKA+T; SOT-23-8
U5: MT6701CT-ACD; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C2.1, C3.1, C12.2, C21.1, C22.2, D1.2 (A), D2.2 (A), FB3.2, J1.1, J6.1, J11.1, J11.2, R3.1, R4.1, R26.1, R27.1, U3.1 (VDD), U4.3 (VCC), U5.1 (VDD), U5.2 (MODE); also elsewhere on the board
+3V3DC: C11.2, FB3.1; also elsewhere on the board
/CH32L103/BOOT1: R2.1, U3.16 (PB2/BOOT1)
/CH32L103/CAN1_RX: U3.4 (OSC_IN/PD0), U4.4 (RXD)
/CH32L103/CAN1_TX: U3.5 (OSC_OUT/PD1), U4.1 (TXD)
/CH32L103/CANH: R12.1, U1.1, U4.7 (CANH)
/CH32L103/CANL: R12.2, U1.2, U4.6 (CANL)
/CH32L103/Chang_Speed: U3.11 (PA5/ADC5)
/CH32L103/LED_ERR: R21.2, U3.3 (PC15/OSC32OUT)
/CH32L103/LED_OK: R17.2, U3.2 (PC14/OSC32IN)
/CH32L103/SWCLK: J1.2, U3.24 (PA14/SWCLK)
/CH32L103/SWDIO: J1.3, U3.23 (PA13/SWDIO)
/CH32L103/U1_RX: J1.4, U3.20 (PA10)
/CH32L103/U1_TX: J1.5, U3.19 (PA9)
ADC0: U3.6 (PA0/WKUP/ADC0); also elsewhere on the board
ENC_CLK: J11.3, R3.2, U3.29 (PB6/CC1), U5.7 (B)
ENC_CS: J11.5, R1.1, U3.31 (BOOT0/PB9), U5.8 (Z)
ENC_DO: J11.4, R4.2, U3.32 (PB8), U5.6 (A)
EN_A: U3.28 (PB5); also elsewhere on the board
EN_B: U3.27 (PB4); also elsewhere on the board
EN_C: U3.26 (PB3); also elsewhere on the board
GND: C2.2, C3.2, C11.1, C12.1, C21.2, C22.1, J1.6, J6.4, J6.5, J6.6, J11.6, J11.7, J11.8, R1.2, R2.2, U3.33 (VSS), U4.2 (GND), U4.5 (SHDN), U4.8 (RS), U5.4 (GND); also elsewhere on the board
I2C_SCL: J6.3, R27.2, U3.22 (PA12/UDP)
I2C_SDA: J6.2, R26.2, U3.21 (PA11/UDM)
MOT_A_V: U3.7 (PA1/ADC1); also elsewhere on the board
MOT_B_V: U3.8 (PA2/ADC2); also elsewhere on the board
MOT_C_V: U3.9 (PA3/ADC3); also elsewhere on the board
unnamed: D1.1 (K), R17.1
unnamed: D2.1 (K), R21.1
PWM_A: U3.14 (PB0/ADC8); also elsewhere on the board
PWM_B: U3.13 (PA7/ADC7); also elsewhere on the board
PWM_C: U3.12 (PA6/ADC6); also elsewhere on the board
nFAULT: U3.18 (PA8); also elsewhere on the board
nSLEEP: U3.17 (PB15); also elsewhere on the board

Notes on the sheet:
MT6701走SSI(SPI): DO=PIN6 CLK=PIN7 CSN=PIN8 MODE(PIN2)接+3V3; OUT(PIN3)/PUSH(PIN5)不用
| **G1H**(A 相上管 P 栅 PWM) | PA6 | TIM3_CH1, 20kHz, 有效电平=导通 | | **G2H**(B 相上管 P 栅 PWM) | PA7 | TIM3_CH2, 20kHz, 有效电平=导通 | | **G1L**(A 相下管 N 栅) | PB3 | GPIO, 高=导通(默认低) | | **G2L**(B 相下管 N 栅) | PB4 | GPIO, 高=导通(默认低) |
编码器：SSI 与 I2C 共用同一对线，MODE=+3V3 已选定 I2C/SSI 走 I2C：CSN 需全程拉高，从机地址 0x06 走 SSI：CSN 当片选，需拉高再拉低成帧 PB9 的 R1(4.7k) 是 BOOT0 必需下拉，不是片选偏置

Board: 2 copper layers, 46.0 x 46.0 mm, 82 parts (23 on the bottom side), 60 nets.

## Code that names these connections

File firmware/User/board.h (part):

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 *   本工程: 20kHz 固定节拍电流环 + 1kHz 速度环 + 200Hz 位置环 (见 docs\)
 *
 * 引脚与网表的对应 **一个字都没改** (原理图 2026-10-18 已冻结, 不再动):
 *   PWM_A  = PB0 -> U6.27 INHA  TIM3_CH3
 *   PWM_B  = PA7 -> U6.29 INHB  TIM3_CH2
 *   PWM_C  = PA6 -> U6.31 INHC  TIM3_CH1     <-- 本板 A/C 相对旧板对调过
 *   EN_A/B/C = PB5 / PB4 / PB3 -> U6.28 / 30 / 32 (INLA/B/C)
 *   nSLEEP = PB15, nFAULT = PA8 (R46 5.1k 上拉, 开漏)
 *   MOT_A_V= PA1 <- SOA ; MOT_B_V= PA2 <- SOB ; MOT_C_V= PA3 <- SOC  (8316C 内部 CSA)
 *   ADC0   = PA0 母线分压
 *   ENC_CLK= PB6 -> U5.7 ; ENC_DO= PB8 <- U5.6 ; ENC_CS= PB9 -> U5.8  (MT6701 SSI)
 *   CAN1   = PD0(RX) / PD1(TX) ; UART1 = PA9(TX) / PA10(RX)
 * 时钟: HSI 96MHz (system_ch32l103.c SetSysClockTo96_HSI, 未改)
 * ========================================================================== */

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#define ENC_READ_DIV            4u

/* ---- 三相电流采样: DRV8316C 内置低边 sense-FET + 内部 CSA ----
 * 通道 idx 0/1/2 = A/B/C = PA1/PA2/PA3 = ADC_Channel_1/2/3
 * GAIN 脚悬空 = 0.3 V/A (R49/R50 都不贴, 依据 board.h(旧) 四电平脚表 + 手册 SLVSH07)
 * VLINEAR = 0.25..3.05V, 中点 VREF/2 = 1.65V -> 满量程 ±4.667A (算术值, 未实测)
 * 零点不用 1.65V: 上电 DRV 未使能时实测 (cs_zero_cal) */
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
#define MOTOR_VBUS_DEF         24.0f       /* 母线默认值 (设计值); 有分压采样时以实测为准 */

/* ---- CAN1 (U4 = MAX3051EKA+T, PD0=RX / PD1=TX) ----
 * 位时序沿用旧工程 2026-08-xx 在本板实测跑通的那组:
 *   PCLK1 = 48MHz (SystemCoreClock 96MHz / PPRE1_DIV2, 见 system_ch32l103.c),
 *   Prescaler=2 -> tq = 24MHz, 1 + BS1(15) + BS2(8) = 24 tq -> 1 Mbps。
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
File firmware/User/drv8316c.c:

#include "drv8316c.h"
#include "board.h"
#include "debug.h"

/* =============================================================================
 * DRV8316C 硬件层 (CH32L103) —— 从 drv8313.c 移植
 *   PWM   : TIM3 CH1/CH2/CH3 -> PA6 / PA7 / PB0, 中心对齐 20kHz
 *   EN    : PB5 / PB4 / PB3 (EN_A / EN_B / EN_C)
 *   nSLEEP: PB15 推挽输出, 高 = 工作 (内部 150/200/300k 下拉 -> 复位期间天然睡眠)
 *   nFAULT: PA8 输入上拉 (R46 5.1k -> +3V3)
 *
 * 相名与定时器通道的对应 (网表实据 2026-10-08, 旧板 A=CH1/B=CH2/C=CH3, 本板 A/C 对调):
 *   A 相: PB0 = TIM3_CH3   U6.27 INHA -> OUTA;  U6.40 SOA -> MOT_A_V -> PA1 = ADC_Channel_1
 *   B 相: PA7 = TIM3_CH2   U6.29 INHB -> OUTB;  U6.39 SOB -> MOT_B_V -> PA2 = ADC_Channel_2
 *   C 相: PA6 = TIM3_CH1   U6.31 INHC -> OUTC;  U6.38 SOC -> MOT_C_V -> PA3 = ADC_Channel_3
 * 这张表写错的话: PWM 会与采样的相错位 -> 力矩方向错/FOC 抖, 且电流会读错相。
 * ========================================================================== */

void DRV8316C_Init(void)
{
    GPIO_InitTypeDef        gpio;
    TIM_TimeBaseInitTypeDef tb;
    TIM_OCInitTypeDef       oc;

    RCC_PB2PeriphClockCmd(RCC_PB2Periph_GPIOA | RCC_PB2Periph_GPIOB |
                          RCC_PB2Periph_GPIOC | RCC_PB2Periph_AFIO, ENABLE);
    RCC_PB1PeriphClockCmd(RCC_PB1Periph_TIM3, ENABLE);

    /* ---- PWM 输出: PA6(TIM3_CH1=C) / PA7(TIM3_CH2=B) / PB0(TIM3_CH3=A), 复用推挽 ---- */
    gpio.GPIO_Speed = GPIO_Speed_50MHz;
    gpio.GPIO_Mode  = GPIO_Mode_AF_PP;

    gpio.GPIO_Pin = GPIO_Pin_6 | GPIO_Pin_7;
    GPIO_Init(GPIOA, &gpio);

    gpio.GPIO_Pin = GPIO_Pin_0;
    GPIO_Init(GPIOB, &gpio);

    /* ---- EN_A/B/C: 推挽输出, 先拉低 (高阻) ---- */
    gpio.GPIO_Mode = GPIO_Mode_Out_PP;
    gpio.GPIO_Pin  = GPIO_Pin_3 | GPIO_Pin_4 | GPIO_Pin_5;
    GPIO_Init(GPIOB, &gpio);
    GPIO_ResetBits(GPIOB, GPIO_Pin_3 | GPIO_Pin_4 | GPIO_Pin_5);

    /* ---- nSLEEP (PB15): 输出, 先低 = 睡眠 ---- */
    gpio.GPIO_Mode = GPIO_Mode_Out_PP;
    gpio.GPIO_Pin  = GPIO_Pin_15;
    GPIO_Init(GPIOB, &gpio);
    GPIO_ResetBits(GPIOB, GPIO_Pin_15);

    /* ---- nFAULT (PA8): 输入上拉 ---- */
    gpio.GPIO_Mode = GPIO_Mode_IPU;
    gpio.GPIO_Pin  = GPIO_Pin_8;
    GPIO_Init(GPIOA, &gpio);

    /* ---- TIM3: 中心对齐, 20kHz (96MHz / (2*2400)) ---- */
    TIM_DeInit(TIM3);
    tb.TIM_Prescaler         = 0;
    tb.TIM_Period            = (uint16_t)PWM_ARR();
    tb.TIM_CounterMode       = TIM_CounterMode_CenterAligned1;
    tb.TIM_ClockDivision     = TIM_CKD_DIV1;
    tb.TIM_RepetitionCounter = 0;
    TIM_TimeBaseInit(TIM3, &tb);

    oc.TIM_OCMode      = TIM_OCMode_PWM1;
    oc.TIM_OutputState = TIM_OutputState_Enable;
    oc.TIM_OCPolarity  = TIM_OCPolarity_High;
    oc.TIM_Pulse       = 0;
    oc.TIM_OutputNState = TIM_OutputNState_Disable;
    oc.TIM_OCNPolarity  = TIM_OCNPolarity_High;
    oc.TIM_OCIdleState  = TIM_OCIdleState_Reset;
    oc.TIM_OCNIdleState = TIM_OCNIdleState_Reset;

    TIM_OC1Init(TIM3, &oc);
    TIM_OC2Init(TIM3, &oc);
    TIM_OC3Init(TIM3, &oc);

    /* CH4 不出脚 (对应引脚没配复用), 只借它的比较匹配当"峰值"标记。
     * CCR4 = ARR -> 中心对齐下每个载波周期只在顶部匹配一次, CC4IF 一拍只置一次。
     * 为什么要它: 原来靠读 CNT (> ARR/2 判峰值) 分峰/谷, 一旦某拍中断被上一拍
     * 拖晚 (1kHz 速度环那拍实测 44us > 半个周期 25us), CNT 已经落到下半区,
     * 峰值被判成谷值 —— 2026-10-18 上板量到 5.26% 的周期因此丢了编码器采样和
     * ADC 触发, 谷值处理多跑 11% (开环转速看着偏高 10% 就是它)。 */
    TIM_OC4Init(TIM3, &oc);
    TIM_SetCompare4(TIM3, (uint32_t)PWM_ARR());

    TIM_OC1PreloadConfig(TIM3, TIM_OCPreload_Enable);
    TIM_OC2PreloadConfig(TIM3, TIM_OCPreload_Enable);
    TIM_OC3PreloadConfig(TIM3, TIM_OCPreload_Enable);
    TIM_ARRPreloadConfig(TIM3, ENABLE);

    TIM_Cmd(TIM3, ENABLE);

    /* ---- 唤醒 8316C: nSLEEP 拉高 + 等 tWAKE ----
     * tWAKE = 1ms (nSLEEP=1 -> outputs ready 且 nFAULT 释放; 手册 SLVSH07 L598-599)。
     * 必须在 Delay_Init() 之后调 DRV8316C_Init()。 */
    GPIO_SetBits(GPIOB, GPIO_Pin_15);
    /* 2026-10-13 改成 2ms: 手册 SLVSH07 电气表 tWAKE = 1ms(typ, 无 max 列) 是
     * "nSLEEP=1 到 outputs ready 且 nFAULT released" 的时间, 而且手册 §8.4.1
     * 明确写 "nFAULT 在 nSLEEP 上电期间会被拉低, 时长不超过 tWAKE" —— 也就是说
     * 刚唤醒时读到 nFAULT=1 是**正常现象**, 不是故障。原来等 1ms 正好压在 typ 值上,
     * 实测 banner 那行时不时读到 nFAULT=1 (运行起来再读就是 0), 就是压线造成的。
     * 2ms = 2 倍 typ 余量 (设计取值, 未实测最小需要多久)。 */
    Delay_Ms(2);
}

void DRV8316C_Enable(void)
{
    GPIO_SetBits(GPIOB, GPIO_Pin_3 | GPIO_Pin_4 | GPIO_Pin_5);
}

void DRV8316C_Disable(void)
{
    /* 注意: 清 CCR 只是让 INHx=0(低边); 真正把桥变成高阻的是 INLx=0 */
    TIM_SetCompare1(TIM3, 0);
    TIM_SetCompare2(TIM3, 0);
    TIM_SetCompare3(TIM3, 0);
    GPIO_ResetBits(GPIOB, GPIO_Pin_3 | GPIO_Pin_4 | GPIO_Pin_5);
}

int DRV8316C_IsEnabled(void)
{
    return (int)((GPIO_ReadOutputDataBit(GPIOB, GPIO_Pin_3) &&
                  GPIO_ReadOutputDataBit(GPIOB, GPIO_Pin_4) &&
                  GPIO_ReadOutputDataBit(GPIOB, GPIO_Pin_5)) ? 1 : 0);
}

static float last_duty[3];

void DRV8316C_SetDuty(float ta, float tb, float tc)
{
    uint32_t arr = (uint32_t)PWM_ARR();

    if(ta < 0.0f) ta = 0.0f; else if(ta > 1.0f) ta = 1.0f;
    if(tb < 0.0f) tb = 0.0f; else if(tb > 1.0f) tb = 1.0f;
    if(tc < 0.0f) tc = 0.0f; else if(tc > 1.0f) tc = 1.0f;

    last_duty[0] = ta; last_duty[1] = tb; last_duty[2] = tc;

    /* A -> CH3(PB0) / B -> CH2(PA7) / C -> CH1(PA6); 见文件头相名对照表 */
    TIM_SetCompare3(TIM3, (uint32_t)(ta * (float)arr));
    TIM_SetCompare2(TIM3, (uint32_t)(tb * (float)arr));
    TIM_SetCompare1(TIM3, (uint32_t)(tc * (float)arr));
}

void DRV8316C_GetDuty(float *ta, float *tb, float *tc)
{
    *ta = last_duty[0]; *tb = last_duty[1]; *tc = last_duty[2];
}

uint8_t DRV8316C_Faulted(void)
{
    return (GPIO_ReadInputDataBit(GPIOA, GPIO_Pin_8) == Bit_RESET) ? 1 : 0;
}

uint8_t DRV8316C_nSLEEP(void)
{
    return (GPIO_ReadOutputDataBit(GPIOB, GPIO_Pin_15) != 0) ? 1u : 0u;
}

void DRV8316C_PwmIT_Enable(void)
{
    NVIC_InitTypeDef nvic = {0};

    TIM_ClearITPendingBit(TIM3, TIM_IT_Update | TIM_IT_CC4);
    TIM_ITConfig(TIM3, TIM_IT_Update | TIM_IT_CC4, ENABLE);

    /* 抢占优先级给最高: 电流采样必须落在载波顶那一小段窗口里, 不能被别的 ISR 挤晚。
     * (TIM1 的 3kHz 驱动中断是 1, CAN 是 3; NVIC 分组见 main.c) */
    nvic.NVIC_IRQChannel                   = TIM3_IRQn;
    nvic.NVIC_IRQChannelPreemptionPriority = 0;
    nvic.NVIC_IRQChannelSubPriority        = 0;
    nvic.NVIC_IRQChannelCmd                = ENABLE;
    NVIC_Init(&nvic);
}

void DRV8316C_PwmIT_Disable(void)
{
    TIM_ClearITPendingBit(TIM3, TIM_IT_Update | TIM_IT_CC4);
    TIM_ITConfig(TIM3, TIM_IT_Update | TIM_IT_CC4, DISABLE);
}

/* ---- TIM4: 32 位自由运行计数器, 1MHz, 供 FOC 计算 Ts ---- */
void Micros_Init(void)
{
    TIM_TimeBaseInitTypeDef tb;

    RCC_PB1PeriphClockCmd(RCC_PB1Periph_TIM4, ENABLE);

    TIM_DeInit(TIM4);
    tb.TIM_Prescaler         = (uint16_t)(SystemCoreClock / 1000000u - 1u);
    tb.TIM_Period            = 0xFFFFFFFFu;
    tb.TIM_CounterMode       = TIM_CounterMode_Up;
    tb.TIM_ClockDivision     = TIM_CKD_DIV1;
    tb.TIM_RepetitionCounter = 0;
    TIM_TimeBaseInit(TIM4, &tb);

    TIM_Cmd(TIM4, ENABLE);
}

uint32_t Micros(void)
{
    return TIM4->CNT_TIM4;
}

File firmware/User/can_bus.c (part):

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    fb_on  = 1;          /* 子开关默认可用 */
    dbg_on = 0;          /* 但总闸默认关: 上电即被动, 不主动发任何帧 */

    /* CAN 挪到 PD0(RX) / PD1(TX) —— 旧板的 PB8/PB9 本板给了编码器 (ENC_DO/ENC_CS)。
     * 依据 (2026-10-08 从应用手册 AFIO_PCFR1 位域原文核过, 手册 V1.9 L5182-5199):
     *   bit15   PD0PD1_RM : 0 = PD0/PD1 当晶振脚 / 1 = 当 GPIO 用 (复位值 0)
     *   [14:13] CAN_RM    : 00 = PA11/PA12, 10 = PB8/PB9, 01 = 保留,
     *                       11 = CAN_RX -> PD0, CAN_TX -> PD1
     * 本板 PD0/PD1 上没挂晶振 (PD0->U4.4 RXD, PD1->U4.1 TXD), 时钟走 HSI
     * (User\system_ch32l103.c SetSysClockTo96_HSI), 所以两位都要写。
     * 直接写寄存器, 不用 GPIO_Remap* 宏 —— 宏的编码跟位域位置绑着, 写位域不歧义。 */
    RCC_PB2PeriphClockCmd(RCC_PB2Periph_AFIO | RCC_PB2Periph_GPIOD, ENABLE);

    /* 2026-10-18: 重射先写, CAN 时钟后开。原来是先开 CAN 时钟再写 AFIO,
     * 实测这台板子上 CAN 核没拿到 PD0/PD1 —— TX 不出现在引脚、RX 收到的是乱码
     * (依据: 发一帧 REC 从 9 跳到 129, 而 TXD->RXD 的环路上 'Y' 自检是通的)。
     * 重射位同样是 家规里那两个: b15 PD0PD1_RM=1, CAN_RM[14:13]=11b。 */
    AFIO->PCFR1 |=  (1u << 15);
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
    RCC_PB1PeriphClockCmd(RCC_PB1Periph_CAN1, ENABLE);

    /* PD1 = CAN1_TX: 复用推挽; PD0 = CAN1_RX: 输入上拉 */
    gpio.GPIO_Pin   = GPIO_Pin_1;
    gpio.GPIO_Mode  = GPIO_Mode_AF_PP;
    gpio.GPIO_Speed = GPIO_Speed_50MHz;
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}

/* ---- 收发器(MAX3051)回路自测 (2026-10-18) ----
 * 做法: 把 PD1 临时当普通 GPIO 拉高/拉低, 从 PD0(RXD) 读回总线电平。
 *   通过 = PD1 拉低(显性) 时 PD0 也变 0, 拉高(隐性) 时 PD0 = 1,
 *          说明 MCU 引脚 -> U4.TXD -> CANH/CANL -> U4.RXD -> MCU 这一整圈是通的。
 * 不动运动/驱动状态, 只在串口手动敲 'Y' 时跑。 */
int CAN_Bus_XcvLoopTest(void)
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    gpio.GPIO_Speed = GPIO_Speed_50MHz;
    GPIO_Init(GPIOD, &gpio);

    printf("XCV: PD0 idle=%u | TXD=1 -> PD0=%u%s | TXD=0 -> PD0=%u\r\n",
           (unsigned)idle, (unsigned)hi, hi_ok ? "" : "(抖动)", (unsigned)lo);

    if(!hi_ok || hi != 1u)
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    }
    if(lo != 0u)
    {
        printf("XCV: FAIL - 拉显性后 RXD 不跟着变 (PD1 焊点 / U4.TXD / 驱动级不通)\r\n");
        return 2;
    }
    printf("XCV: OK - 收发器回路通 (PD1 -> U4 -> CANH/L -> U4 -> PD0)\r\n");
    return 0;
}

/* ---- 引脚强制拉低 (2026-10-18) ----
 * 'V0': PD0(4脚) / PD1(5脚) 都配成推挽输出并拉低, 用来量 MCU 焊盘与走线;
 * 'V1': 还原 CAN 用法 (PD1 复用推挽, PD0 输入上拉)。
 * V0 期间总线被拉成显性且与 U4.RXD 对顶, 只在台面上短时间用, 别挂别的节点。 */
void CAN_Bus_PinsLow(int on)
{
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        gpio.GPIO_Speed = GPIO_Speed_2MHz;
        GPIO_Init(GPIOD, &gpio);
        GPIO_ResetBits(GPIOD, GPIO_Pin_0 | GPIO_Pin_1);
        printf("PIN: PD0(4)=0 PD1(5)=0 推挽拉低 保持中 | INDR=0x%04lX CFGLR=0x%08lX\r\n",
               (unsigned long)GPIOD->INDR, (unsigned long)GPIOD->CFGLR);
    }
    else
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        gpio.GPIO_Pin   = GPIO_Pin_0;
        gpio.GPIO_Mode  = GPIO_Mode_IPU;
        GPIO_Init(GPIOD, &gpio);
        printf("PIN: 还原 CAN 用法 (PD1=AF_PP PD0=IPU)\r\n");
    }
}

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
File firmware/User/main.c:

#include "ch32l103.h"
#include "board.h"          /* 必须在 debug.h 之前: 它定义了 DEBUG_BAUD_DEFAULT */
#include "debug.h"
#include "fmt.h"
#include "drv8316c.h"
#include "csense.h"
#include "enc.h"
#include "motor.h"
#include "foc.h"
#include "cmd.h"
#include "motion.h"
#include "can_bus.h"
#include "faults.h"
#include "posstore.h"

/* =============================================================================
 * CH32L103 + DRV8316C  FOC V2  (按 AT32M416 mclib 的骨架重做)
 * -----------------------------------------------------------------------------
 * 主循环只管三件事: 收命令 / 每 10ms 采一次母线电压 / 看 nFAULT。
 * **控制全部在 TIM3 中断里** (20kHz), 主循环再怎么卡也影响不到环路节拍。
 * ========================================================================== */

/* ---- 状态灯 (口径与旧固件 CH32L103_DRV8316C_FOC_CAN 一致) --------------------
 * 绿 D1 (LED_OK , PC14): 阳极->+3V3, 阴极->R17 860R->PC14  —— 灌电流接法, 拉低才亮
 * 红 D2 (LED_ERR, PC15): 阳极->+3V3, 阴极->R21     ->PC15  —— 灌电流接法, 拉低才亮
 *
 *   绿灯 (LED_OK) —— 心跳 / 出力指示
 *     上电        : 立刻常亮 (电和程序都起来了)
 *     停机 / 空闲 : 1 秒翻转一次 (2 秒一个周期)
 *     驱动使能中  : 常亮不闪 (一眼看出正在出力)
 *
 *   红灯 (LED_ERR) —— 状态指示
 *     有故障 / 堵转 : 快闪 (100 ms 翻转一次)
 *     没使能        : 慢闪 (500 ms 翻转一次)
 *     使能且一切正常: 灭
 *     硬故障(MCU崩): 快闪 (见 ch32l103_it.c 的 HardFault_Handler)
 */
/* 红灯当"故障"看的位: 堵转/过流/驱动 nFAULT/编码器/存 Flash 失败/母线低。
 * DISABLED(正常失能)、NOT_ALIGNED(还没对齐)、CMD_REJECT(命令被拒) 不算故障。 */
#define LED_ERR_FAULT_MASK  (CAN_FAULT_STALL | CAN_FAULT_OVERCURRENT | CAN_FAULT_DRV_NFAULT | \
                             CAN_FAULT_SENSOR | CAN_FAULT_FLASH_FAIL | CAN_FAULT_VM_LOW)

static void led_init(void)
{
    GPIO_InitTypeDef gpio;

    RCC_PB2PeriphClockCmd(RCC_PB2Periph_GPIOC, ENABLE);
    gpio.GPIO_Pin   = GPIO_Pin_14 | GPIO_Pin_15;
    gpio.GPIO_Mode  = GPIO_Mode_Out_PP;
    gpio.GPIO_Speed = GPIO_Speed_10MHz;
    GPIO_Init(GPIOC, &gpio);
    GPIO_ResetBits(GPIOC, GPIO_Pin_14);                 /* 绿灯: 上电即亮 */
    GPIO_SetBits(GPIOC, GPIO_Pin_15);                   /* 红灯: 灭 */
}

static void banner(void)
{
    uint16_t raw = 0;
    uint8_t  crc_ok = 0;
    float ia, ib, ic;

    printf("\r\n=== CH32L103 + DRV8316C FOC V2 (build %s %s) ===\r\n", __DATE__, __TIME__);
    printf("CLK:%lu  PWM:%luHz  Ts:%sus\r\n",
           (unsigned long)SystemCoreClock, (unsigned long)PWM_FREQ_HZ,
           FmtF(PWM_TS_S * 1e6f, 2));
    printf("LOOP: cur=%luHz spd=%luHz pos=%luHz enc=%luHz  pll_bw=%sHz\r\n",
           (unsigned long)(PWM_FREQ_HZ / CUR_LOOP_DIV),
           (unsigned long)(PWM_FREQ_HZ / SPD_LOOP_DIV),
           (unsigned long)(PWM_FREQ_HZ / POS_LOOP_DIV),
           (unsigned long)PWM_FREQ_HZ, FmtF(Enc_PllBandwidth(), 0));

    printf("DRV: nSLEEP=%u nFAULT=%u\r\n", (unsigned)DRV8316C_nSLEEP(), (unsigned)DRV8316C_Faulted());
    (void)Enc_ReadBlocking(&raw, &crc_ok);
    printf("ENC: raw=%u crc=%s\r\n", (unsigned)raw, crc_ok ? "OK" : "MISMATCH");
    printf("CSA: zerov A=%s B=%s C=%s | selftest jeoc=%u ok=%u JDR=%u/%u/%u\r\n",
           FmtF(CS_ZeroVolt(0), 4), FmtF(CS_ZeroVolt(1), 4), FmtF(CS_ZeroVolt(2), 4),
           (unsigned)CS_SelfTestJeoc(), (unsigned)CS_SelfTestOk(),
           (unsigned)CS_SelfTestJdr(0), (unsigned)CS_SelfTestJdr(1), (unsigned)CS_SelfTestJdr(2));
    CS_GetIsr(&ia, &ib, &ic);
    printf("CSA: 当前 ia=%s ib=%s ic=%s A (DRV 未使能时应≈0)\r\n",
           FmtF(ia, 3), FmtF(ib, 3), FmtF(ic, 3));
    printf("VM: %s V (分压比 %s)\r\n", FmtF(CS_VM_Volt(), 2), FmtF(VM_DIVIDER_RATIO, 3));
    {
        float kp, ki;
        Motor_GetCurGains(&kp, &ki);
        printf("GAIN: cur kp=%s V/A ki=%s V/(A*s) | pp=%d\r\n",
               FmtF(kp, 4), FmtF(ki, 1), Motor_PolePairs());
    }
}

int main(void)
{
    uint32_t t_led, t_red, t_vm, t_try = 0;
    uint8_t  led_on = 1u;               /* 1 = 绿灯亮 */
    uint8_t  red_on = 0u;               /* 1 = 红灯亮 */

    NVIC_PriorityGroupConfig(NVIC_PriorityGroup_1);
    SystemCoreClockUpdate();
    Delay_Init();
    USART_Printf_Init(DEBUG_BAUD_DEFAULT);
    UsartTx_Init();
    led_init();

    Micros_Init();

    DRV8316C_Init();       /* TIM3 起振, nSLEEP 拉高, EN 保持低 (桥高阻) */
    CS_Init();             /* ADC 注入组 + 上电自检 */
    CS_CalZero();          /* 此刻 DRV 没使能, 相电流为 0 -> 正是零点 */
    Enc_Init();
    PosStore_Init();       /* 读 Flash 里的机械零点/圈数, 恢复掉电前的位置 */
    Motor_Init();
    Motion_Init();         /* 读 Flash 里的节点号/极对数/电流上限/母线, 覆盖编译默认 */
    Motion_SetHomeFlag(PosStore_HomeSet());
    Cmd_Init();
    CAN_Bus_Init();        /* CAN1: PD0/PD1, 1Mbps */
    Fault_Init();

    DRV8316C_SetDuty(0.5f, 0.5f, 0.5f);   /* 零矢量, 等中断接管 */
    banner();
    printf("CAN: %s node=%d (1..63, 0=广播) | '%' 看/设节点号, 'K' 看 CAN 状态, 'J' 发测试帧\r\n",
           CAN_Bus_Ready() ? "ready" : "NOT ready", Motion_Node());
    printf("SAFE: 驱动未使能, 桥高阻。输入 'e' 使能, '?' 看状态, 'Q' 看诊断\r\n");

    /* 打开 TIM3 更新中断 —— 从这一刻起控制环才开始跑 */
    DRV8316C_PwmIT_Enable();

    t_led = Micros() + 1000000u;
    t_red = Micros();
    t_vm  = Micros();

    while(1)
    {
        uint32_t now;

        Cmd_Poll();
        CAN_Bus_Task();     /* 收命令 + (打开时) 周期反馈 */
        Motion_Task();      /* 板载动作脚本状态机 */
        Fault_Task();       /* 故障位图 + 主动上报 */
        PosStore_Tick(Micros());          /* 停稳 3s 存一次位置 (写 Flash 只在这里发生) */

        /* 原始角诊断流: 'SD1' 打开后主循环把 MT6701 的原始计数直出给上位机 */
        if(Enc_CapEnabled())
        {
            uint16_t cr;
            uint32_t cs;

            if(Enc_CapRead(&cr, &cs)) printf("%X,%X\r\n", (unsigned)(cs & 0xFFFu), (unsigned)cr);
        }

        now = Micros();

        /* 母线电压: 10ms 一次就够 (主循环卡一下也不影响环路) */
        if((int32_t)(now - t_vm) >= 0)
        {
            float vm;
            t_vm = now + 10000u;
            vm = CS_VM_Volt();
            if(vm > 1.0f) Motor_SetVbus(vm);
        }

        /* nFAULT 低 -> 失能, 但不在中断/主循环里死等 (旧固件那个 while(1) 会把 CAN 一起弄哑) */
        if(DRV8316C_Faulted())
        {
            if((int32_t)(now - t_try) >= 0)
            {
                t_try = now + 1000000u;
                Motor_SetFault(2u);        /* 2 = 8316C 的 nFAULT 被拉低 */
                Motor_Disable();
                printf("ERR nFAULT 低 -> 已失能; 查故障后 'X' 清除再 'e'\r\n");
            }
        }

        /* 绿灯: 停机时 1 秒翻转一次; 使能中常亮 (与旧固件一致) */
        if((int32_t)(now - t_led) >= 0)
        {
            t_led = now + 1000000u;
            if(Motion_IsEnabled())
            {
                if(!led_on) { GPIO_ResetBits(GPIOC, GPIO_Pin_14); led_on = 1u; }
            }
            else
            {
                led_on = (uint8_t)!led_on;
                if(led_on) GPIO_ResetBits(GPIOC, GPIO_Pin_14);
                else       GPIO_SetBits(GPIOC, GPIO_Pin_14);
            }
        }

        /* 红灯: 故障/堵转 -> 快闪; 没使能 -> 慢闪; 使能且正常 -> 灭 */
        {
            uint32_t period;

            if(Motion_IsStalled() || (Fault_Active() & LED_ERR_FAULT_MASK) != 0u)
                period = 100000u;      /* 快闪: 100ms 翻一次 */
            else if(!Motion_IsEnabled())
                period = 500000u;      /* 慢闪: 500ms 翻一次 */
            else
                period = 0u;           /* 正常: 灭 */

            if(period == 0u)
            {
                if(red_on) { GPIO_SetBits(GPIOC, GPIO_Pin_15); red_on = 0u; }
                t_red = now;           /* 灭着的时候把计时从头算, 恢复时不会先蹦半拍 */
            }
            else if((int32_t)(now - t_red) >= 0)
            {
                t_red = now + period;
                red_on = (uint8_t)!red_on;
                if(red_on) GPIO_ResetBits(GPIOC, GPIO_Pin_15);
                else       GPIO_SetBits(GPIOC, GPIO_Pin_15);
            }
        }
    }
}
